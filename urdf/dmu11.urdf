Commit message: Small changes in naming and documentation
not tested

File: urdf/dmu11.urdf (robot description, URDF)
Before this commit: robot dmu11, 1 links, 0 joints
Links:
- link imu: geometry visual mesh filename=package://dmu_ros/meshes/dmu11.stl scale=0.1 0.1 0.1
